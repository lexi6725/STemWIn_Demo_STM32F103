# Keil uVision project RemoteCar.uvprojx, settings and files
target RemoteCar (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RemoteCar
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../GUI/inc;../GUI/config;../Demo
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/User
    ../Src/: main.c usart.c stm32f1xx_hal_msp.c bsp_driver_sd.c usb.c i2c.c tim.c freertos.c fsmc.c stm32f1xx_it.c sdio.c crc.c fatfs.c gpio.c iwdg.c rtc.c spi.c fonts.c stm3210e_eval_lcd.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_cortex.c stm32f1xx_hal_sram.c stm32f1xx_hal_sd.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_pwr.c stm32f1xx_hal_crc.c stm32f1xx_hal_rtc.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_rcc_ex.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c list.c croutine.c tasks.c timers.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group GUI/Config
    ../GUI/config/: GUIConf.c GUIDRV_R61505R.c LCDConf_FlexColor.c
  group GUI/Libs
    ../GUI/lib/: STemWin522_CM3_OS_Keil.lib
  group GUI/Src
    ../GUI/: GUI_X_FreeRTOS.c
  group DEMO
    ../Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
software components: CMSIS:CORE 4.1.0
